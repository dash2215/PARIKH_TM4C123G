# Keil uVision project ECE473lab3.uvproj, settings and files
target ECE473Lab3 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: EE383lab4
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ECE473lab3.c
  group Dependencies
    ./driverlib/: gpio.c sysctl.c uart.c adc.c interrupt.c cpu.c systick.c
    ./utils/: uartstdio.c
