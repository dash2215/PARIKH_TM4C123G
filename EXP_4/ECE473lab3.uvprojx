# Keil uVision project ECE473lab3.uvprojx, settings and files
target ECE473Lab3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EE383lab4
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: startup.s ECE473lab3.c
  group Dependencies
    ./driverlib/: gpio.c sysctl.c uart.c adc.c interrupt.c cpu.c systick.c
    ./utils/: uartstdio.c
software components: CMSIS:CORE 5.1.2
